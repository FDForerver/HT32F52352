# Keil uVision project template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HT32F52352_64LQFP Holtek
  pack: Holtek.HT32_DFP.1.0.16
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1FE00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\Code;..\Code\Include;..\Library\inc;..\Config;..\Utilities\common;..\Hardware\LED;..\Hardware\USART;..\Utilities;..\Utilities\HT32_Board;..\Hardware\TJC_T0;..\User;..\NET\device\inc;..\NET\onenet\inc;..\NET\MQTT;..\Hardware;..\NET\CJSON;..\Hardware\time;..\Hardware\dht11
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ./: ht32f5xxxx_01_it.c main.c delay.c
  group Hardware
    ../Hardware/LED/: led.c
    ../Hardware/USART/: usart.c usart.h
    ../Hardware/time/: time.c
    ../Hardware/dht11/: dht11.c
  group Config
    ../Config/: ht32_board_config.h ht32_op.s HT32F5xxxx_01_DebugSupport.ini ht32f5xxxx_01_usbdconf.h ht32f5xxxx_conf.h startup_ht32f5xxxx_01.s
  group Code
    ../Code/: ht32_usbd_core.c system_ht32f5xxxx_01.c
  group Library
    ../Library/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group Utilities
    ../Utilities/: ht32_board.c ht32_retarget.c ht32_serial.c
    ../Utilities/common/: i2c_eeprom.c
  group Doc
    ../Doc/: readme.txt
  group ESP8266
    ../NET/device/inc/: esp8266.h
    ../NET/device/src/: esp8266.c
  group ONENET
    ../NET/onenet/inc/: onenet.h
    ../NET/onenet/src/: onenet.c
    ../NET/MQTT/: MqttKit.c MqttKit.h Common.h
    ../NET/CJSON/: cJSON.c
